JUMP start

end:
	JUMP end

data_title:
	BYTES 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF
	BYTES 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7
	BYTES 0xFF, 0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF, 0xFF
	BYTES 0xFF, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0
	BYTES 0xFF, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF, 0xFF, 0xE7, 0xE7, 0xFF, 0xFF, 0xFF

data_subtitle:
	BYTES 0xEA, 0xAE, 0xC4, 0xA4, 0xE4
	BYTES 0xAE, 0xE4, 0xE4, 0xA4, 0xAE
	BYTES 0xEE, 0x84, 0xE4, 0x24, 0xE4
	BYTES 0xEE, 0x8A, 0xCC, 0x8A, 0xEA
	BYTES 0xE8, 0xA8, 0xC8, 0xA8, 0xAE
	BYTES 0xAE, 0xA8, 0xA8, 0xA8, 0xEE
	BYTES 0xA0, 0xA0, 0xC0, 0xA0, 0xA0

start:
	CLS
	STOR V0, 3		# Starting X position
	STOR V1, 2		# Starting Y position
	STOR V2, 0xB	# Offset of each letter on the screen
	STOR I, data_title

	STOR V3, 4		# Counter for the loop; How many letters there are
	STOR V4, 0xF	# Offset of each letter in memory
	STOR V5, 1		# The number one; for decrementing the counter

loop_title:
	# Draw CHIP
	DRAW V0, V1, 0xF # Draw the current letter
	ADD V0, V2		# Add the coord offset to X
	ADD I, V4		# Offset the index register
	SUBR V3, V5		# Decrement the counter by one
	SKE V3, 00		# Skip the jump if counter is at 0
	JUMP loop_title	# Loop

	# Draw `8`
	ADD V0, 6		# Add 6 to the X position
	DRAW V0, V1, 0xF # Draw the letter `8`

	# Draw first part of subtitle
	STOR V0, 5		# X position
	STOR V1, 0x19	# Y position
	STOR I, data_subtitle
	DRAW V0, V1, 5	# Draw the letters `by`

	# Prep for drawing the rest of the subtitle
	ADD V0, 0xA		# X position
	STOR V2, 8		# Offset between letters on the screen
	STOR V3, 5		# Offset between letters in memory
	STOR V4, 6		# Counter; How many letters
	ADD I, V3		# Move index to first letter

loop_subtitle:
	DRAW V0, V1, 5	# Draw the letter
	ADD V0, V2		# Offset the x position
	ADD I, V3		# Offset the index register
	SUBR V4, V5		# Decrement counter
	SKE V4, 00		# Skip if counter is 0
	JUMP loop_subtitle

# So that it loops forever
	JUMP end
